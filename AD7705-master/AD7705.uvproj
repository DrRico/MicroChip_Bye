# Keil uVision project AD7705.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: AD7705 +hex
  c flags: Optimize=8
  group Source Group 1
    ./: STARTUP.A51 main.c AD7705.c
