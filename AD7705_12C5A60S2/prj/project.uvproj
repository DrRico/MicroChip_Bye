# Keil uVision project project.uvproj, settings and files
target Target (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: project +hex
  AfterMake: CopyHex.bat
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\src\bsp
  group App
    ../src/: main.c
  group Bsp
    ../src/bsp/: bsp.c bsp_uart.c bsp_tm7705.c bsp_printf.c
  group Doc
    ../doc/: 例程说明.txt
